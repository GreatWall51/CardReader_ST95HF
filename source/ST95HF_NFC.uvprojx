# Keil uVision project ST95HF_NFC.uvprojx, settings and files
target ST95HF_NFC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: READER_ACCESS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_XL, ST95HF, USE_MB1145_BOARD
  c include: .\SysDriver\inc;.\Library;.\Include;.\Library\CMSIS;.\AppLayer;.\DriverLayer;.\HalLayer;.\SysDriver\src;.\Debug;.\ProtocolLayer;.\ProtocolLayer\95HF_P2P;.\ProtocolLayer\95HF_PCD;.\ProtocolLayer\95HF_PICC;.\SysDriver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group AppLayer
    ./AppLayer/: main.c param_mode.c check_mode.c check_card_mode.c rs485_mode.c card_rw_app.c com_func_config.c BT_mode.c
    ./Library/: stm32f0xx_it.c system_stm32f0xx.c
  group ProtocolLayer
    ./ProtocolLayer/95HF_PCD/: lib_PCD.c lib_iso14443Apcd.c lib_iso14443Bpcd.c lib_iso15693pcd.c lib_nfctype5pcd.c lib_wrapper.c lib_NDEF.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_Geo.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Email.c mfos.c mirror-subr.c crypto1.c
    ./ProtocolLayer/: lib_ConfigManager.c memory_manage.c
  group HalLayer
    ./HalLayer/: hal_timer.c hal_BT.c com_hal_layer.c
  group DriverLayer
    ./DriverLayer/: wdg_drv.c timer_drv.c led_drv.c beep_drv.c card_encrypt.c drv_interrupt.c drv_spi.c drv_95HF.c card_read_drv.c card_rw_drv.c check_io_drv.c flash_drv.c lock_drv.c rs485_drv.c uart_drv.c sim_uart_drv.c des.c
  group SysDriver
    ./SysDriver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
    ./SysDriver/: startup_stm32f030.s
  group Debug
    ./Debug/: debug.c debug_uart.c
